# Keil uVision project power.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: power +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c i_0_bsp.c esp8266.c LCD_Routine.c timer_config_int.c vector.c clock.c uart_base.c powermeter.c LCD_Driver_4line.c IIC_Module.c SPI.c spi.h ENC28J60.c Application.c OLED_I2C.c Oled_displayroutine.c
